## boards/shields/atanumpad/Kconfig.defconfig
```kconfig
if SHIELD_ATANUMPAD

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "atanumpad"

endif
```
